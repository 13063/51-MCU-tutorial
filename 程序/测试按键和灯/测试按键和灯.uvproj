# Keil uVision project 测试按键和灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 测试按键和灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRIVERS
  group Source Group 1
    ./DRIVERS/: key.c led.c public.c
    ./: main.c
