# Keil uVision project oledTime.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: oledTime +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRIVERS;.\src
  group Source Group 1
    ./: main.c
    ./DRIVERS/: ds1302.c key.c public.c ssd1306.c iic.c
