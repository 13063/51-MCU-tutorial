# Keil uVision project ds1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRIVERS
  group Source Group 1
    ./: main.c
    ./DRIVERS/: key.c lcd1602.c led.c public.c ds1302.c
